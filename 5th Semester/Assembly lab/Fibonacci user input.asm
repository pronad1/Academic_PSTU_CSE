;INPUT
MOV AH, 01H
INT 21H
       
;NEWLINE
;MOV AH,02
;MOV DL,0AH
;INT 21H
;MOV DL,0DH
;INT 21H
;

MOV CL,AL

Include 'EMU8086.INC'


SUB CL,48 
SUB CL,0002H
 
MOV AL,00H
MOV DI,1000H 

MOV [DI],AL
MOV AH,01H
INC DI
MOV [DI],AH
 
;OUTPUT 0 
PRINTN
MOV AH,02H 
MOV DL,AL
ADD DL,48
INT 21H
          
;OUTPUT 1
PRINTN         
MOV AH,02H 
MOV DL,AH
ADD DL,47
INT 21H



L1:

MOV AL,[DI-1]

MOV AH,[DI]


MOV BH,00H

ADD BH,AL

ADD BH,AH

; OUTPUT 1 2 3 5 8 ...   
PRINTN
MOV AH,02H 
MOV DL,BH
ADD DL,48
INT 21H
;

INC DI

MOV [DI],BH

LOOP L1





